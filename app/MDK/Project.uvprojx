# Keil uVision project Project.uvprojx, settings and files
target McuSTUDIO_F470VET6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\Driver\Libraries\Include;..\USER\inc;..\Driver\Components\bsp;..\Driver\Components\gd30ad3344;..\Driver\Components\oled;..\Driver\Components\gd25qxx;..\Driver\Components\ebtn;..\Driver\Components\sdio;..\Driver\Components\fatfs;..\Function\APP;..\Function\sysFunction;..\Protocol;..\Protocol\ringbuffer;..\Protocol\ota_uart;..\Protocol\freemodbus\include;..\Protocol\freemodbus\rtu;..\Protocol\freemodbus\port;..\Protocol\modbus_app;..\common;..\PACK\perf_counter-2.3.3;..\CMSIS\CMSIS_5\CMSIS\Core\Include;..\Driver\Device\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../USER/src/: gd32f4xx_it.c main.c systick.c
  group Driver/Components/bsp
    ../Driver/Components/bsp/: mcu_cimc_gd32f470vet6.c mcu_cimc_gd32f470vet6.h
  group Driver/Components/gd25qxx
    ../Driver/Components/gd25qxx/: gd25qxx.c lfs.c lfs_port.c lfs_util.c
  group Driver/Components/gd30ad3344
    ../Driver/Components/gd30ad3344/: gd30ad3344.c gd30ad3344.h
  group Driver/Components/oled
    ../Driver/Components/oled/: oled.c
  group Driver/Components/ebtn
    ../Driver/Components/ebtn/: bit_array.h ebtn.c ebtn.h
  group Driver/Components/sdio
    ../Driver/Components/sdio/: sdio_sdcard.c
  group Driver/Components/fatfs
    ../Driver/Components/fatfs/: diskio.c ff.c
    ../Driver/Components/fatfs/option/: ccsbcs.c
  group Function/APP
    ../Function/APP/: btn_app.c led_app.c oled_app.c scheduler.c usart_app.c adc_app.c sd_app.c rtc_app.c
  group Function/sysFunction
    ../Function/sysFunction/: led_ctrl.c sys_device.c sys_time.c sys_param.c sys_sample.c sys_storage.c sys_dac.c sys_report.c sys_alarm.c sys_sleep.c sys_baudrate.c sys_ota.c sys_pt100.c
  group Protocol
    ../Protocol/: proto_crc.c proto_frame.c proto_dispatch.c
    ../Protocol/ringbuffer/: ring_buffer.c
    ../Protocol/ota_uart/: ota_uart.c
  group Protocol/FreeModbus
    ../Protocol/freemodbus/: mb.c
    ../Protocol/freemodbus/rtu/: mbrtu.c mbcrc.c
    ../Protocol/freemodbus/functions/: mbfuncinput.c mbutils.c
    ../Protocol/freemodbus/port/: portevent.c portserial.c porttimer.c
  group Protocol/ModbusApp
    ../Protocol/modbus_app/: mb_slave.c mb_registers.c
  group Driver/Libraries
    ../Driver/Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Driver/Libraries/: startup_gd32f450_470.s
  group CMSIS
    ../Driver/Device/GD32F4xx/Source/: system_gd32f4xx.c
  group Utilities
    ../PACK/perf_counter-2.3.3/: perf_counter.c perfc_port_default.c systick_wrapper_ual.s
