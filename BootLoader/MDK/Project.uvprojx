# Keil uVision project Project.uvprojx, settings and files
target McuSTUDIO_F470VET6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\Function\Parameter;..\Function\BootLoader;..\Protocol;..\Driver\Libraries\Include;..\Driver\CMSIS\GD\GD32F4xx\Include;..\Driver\BSP;..\Driver\USART;..\Driver\OLED;..\USER\inc;D:\keil\ARM\PACK\ARM\CMSIS\5.9.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BootLoader_F470.sct
  group User
    ../USER/src/: gd32f4xx_it.c main.c systick.c
  group Function/Parameter
    ../Function/Parameter/: bl_param.h bl_partition.h
  group Function/BootLoader
    ../Function/BootLoader/: bl_core.c
  group Driver/BSP
    ../Driver/BSP/: mcu_cimc_gd32f470vet6.c mcu_cimc_gd32f470vet6.h
  group Driver/USART
    ../Driver/USART/: usart_app.c usart_app.h
  group Protocol
    ../Protocol/: bl_crc32.c bl_crc32.h bl_package.h proto_crc.c proto_frame.c
  group Driver/Peripherals
    ../Driver/Libraries/Source/: gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_i2c.c gd32f4xx_dma.c
  group Driver/OLED
    ../Driver/OLED/: oled.c oled.h oledfont.h
  group Driver/Startup
    ../Driver/Libraries/: startup_gd32f450_470.s
  group Driver/CMSIS
    ../Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
